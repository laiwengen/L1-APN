# Keil uVision project L1_li.uvprojx, settings and files
target L1_li Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: L1_li Configuration +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c misc: --C99
  c include: ..\Inc;  ..\Drivers\STM32F0xx_HAL_Driver\Inc;  ..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;  ..\Drivers\CMSIS\Include;  ..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;  ..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_rtc.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_tim_ex.c
  group Application/MDK-ARM
    ../Src/: tim.c
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
  group Application/User
    ../Src/: dma.c main.c gpio.c adc.c i2c.c rtc.c usart.c stm32f0xx_hal_msp.c stm32f0xx_it.c Button.c CJSON.c Console.c DelayCall.c FPE.c IAP.c Thread.c Tick.c SIM808.c md5.c
    ../Inc/: control.h
software components: CMSIS:CORE 4.3.0
